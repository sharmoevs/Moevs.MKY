# IAR project MK_Y.ewp, settings and files
configuration MOEVS_Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MOEVS_BOARD
  ICCARM.CCIncludePath2: src\; startup; startup\core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MK_Y.bin
  ILINK.IlinkOutputFile: MK_Y.out
  ILINK.IlinkIcfFile: 1986VE1T\Flash1986BE1T.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MOEVS_Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MOEVS_BOARD
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: MK_Y.srec
  group (top)
    src/: coreControl.c
    ./: main.c
  group CAN queue
    src/: canFrameQueue.c canmonitorText.c dataQueue.c linkedList.c
  group control
    src/: angelSensor.c angle_reductosin.c angleFilter.c dus.c dusCalibration.c dusFilter.c engineControl.c gkControlMode.c pidFilter.c pidRegulator.c tangageControl.c
  group dsp
    src/: differentiator.c digitalFilter.c
  group loader
    src/: loaders.c selfLoader.c
  group lowlevel
    src/: adc.c arinc.c can.c dac.c flash1986ve1t.c timers.c
  group src
    src/: arincProtocol.c canmonitor.c canterminal.c debugingInfo.c flashUserData.c global.c SystemInit.c
  group startup
    startup/: define_type.h MDR1986VE1T.h startup_1986BE1x.s
  group startup/core
    startup/core/: core_cm1.c core_cm1.h stdint.h
